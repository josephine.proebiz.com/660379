Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:On]
File name: out_ifc.ifc
Time: 2026-09-02T18:15:21
Author: PETERF-PC\Peter
Organization: Structural Designer
Written by: IFC Database Version: Work
Made in: Tekla Structures 2019i Service Pack 13, IFC Export Version: 4.0.0.0 Nov 2 2021

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: MET-2-142Z16 (252)
In: Undefined
Description: MET-2-142Z16; Material: STEEL/S450GD+Z
Tekla Common - Phase: 1; Class: 3
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 162.7 m2; Height: 142 mm; Width: 113.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: B0(?)
Name | Bottom elevation | Top elevation | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x NOSNÍK | +9.459 | +9.640 | 15.9 | 2.6 | 4577 | 2.58416 | 0.00205489 | 16.1309
4 x NOSNÍK | +8.953 | +9.134 | 15.9 | 2.6 | 4577 | 2.58416 | 0.00205489 | 16.1309
4 x NOSNÍK | +8.304 | +8.485 | 15.9 | 2.6 | 4577 | 2.58416 | 0.00205489 | 16.1309
4 x NOSNÍK | +7.655 | +7.835 | 15.9 | 2.6 | 4577 | 2.58416 | 0.00205489 | 16.1309
4 x NOSNÍK | +7.005 | +7.186 | 15.9 | 2.6 | 4577 | 2.58416 | 0.00205489 | 16.1309
4 x NOSNÍK | +6.356 | +6.537 | 15.9 | 2.6 | 4577 | 2.58416 | 0.00205489 | 16.1309
4 x NOSNÍK | +5.736 | +5.917 | 15.9 | 2.6 | 4577 | 2.58416 | 0.00205489 | 16.1309
32 x NOSNÍK | +9.459 | +9.640 | 12.1 | 2 | 3494 | 1.97291 | 0.00156867 | 12.314
32 x NOSNÍK | +8.953 | +9.134 | 12.1 | 2 | 3494 | 1.97291 | 0.00156867 | 12.314
32 x NOSNÍK | +8.304 | +8.485 | 12.1 | 2 | 3494 | 1.97291 | 0.00156867 | 12.314
32 x NOSNÍK | +7.655 | +7.835 | 12.1 | 2 | 3494 | 1.97291 | 0.00156867 | 12.314
32 x NOSNÍK | +7.005 | +7.186 | 12.1 | 2 | 3494 | 1.97291 | 0.00156867 | 12.314
32 x NOSNÍK | +6.356 | +6.537 | 12.1 | 2 | 3494 | 1.97291 | 0.00156867 | 12.314
32 x NOSNÍK | +5.736 | +5.917 | 12.1 | 2 | 3494 | 1.97291 | 0.00156867 | 12.314

# IfcBeam: MET-2-S142Z16 (132)
In: Undefined
Description: MET-2-S142Z16; Material: STEEL/S235JR
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Weight: 2.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 163.1 m2; Net surface area: 0.3 m2; Height: 142 mm; Width: 113.4 mm; Length: 614 mm
Pset_BeamCommon - LoadBearing: no; Reference: SA0(?)
BaseQuantities - Length: 614 mm; OuterSurfaceArea: 0.34744 m2; NetVolume: 0.000275661 m3; NetWeight: 2.16394 kg
Name | Bottom elevation | Top elevation
20 x SLEEVE | +6.353 | +6.533
20 x SLEEVE | +7.651 | +7.832
20 x SLEEVE | +8.950 | +9.130
18 x SLEEVE | +9.456 | +9.636
18 x SLEEVE | +8.301 | +8.481
18 x SLEEVE | +7.002 | +7.183
18 x SLEEVE | +5.733 | +5.913

# IfcBeam: MET-ATA-142 (20)
In: Undefined
Description: MET-ATA-142
Pset_BeamCommon - LoadBearing: no; Reference: CR0(?)
Tekla Common - Bottom elevation: +9.500; Top elevation: +9.619; Phase: 1; Class: 99
Tekla Quantity - Weight: 0.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 122.7 m2; Net surface area: 0.1 m2; Height: 118.8 mm; Width: 47 mm; Length: 312.6 mm
Name | Material | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
APEX_ANGLE | STEEL/S235JR | 312.615 | 0.0788325 | 0.0000818743 | 0.642713
APEX_ANGLE | STEEL/S235JR | 312.616 | 0.0788327 | 0.0000818744 | 0.642714
APEX_ANGLE | STEEL/S450GD+Z | 312.616 | 0.0788327 | 0.0000818746 | 0.642716
16 x APEX_ANGLE | STEEL/S450GD+Z | 312.616 | 0.0788328 | 0.0000818747 | 0.642716
APEX_ANGLE | STEEL/S450GD+Z | 312.616 | 0.0788328 | 0.0000818747 | 0.642717

# IfcBeam: MET-DIAG-WIRE (76)
In: Undefined
Description: MET-DIAG-WIRE; Material: Undefined/43A
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0 m2; Height: 5 mm; Width: 5 mm
Pset_BeamCommon - LoadBearing: no; Reference: CR0(?)
BaseQuantities - NetWeight: 0 kg
Name | Bottom elevation | Top elevation | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
72 x DIAG TIE | +5.866 | +6.403 | 1880 | 0.0288131 | 0.000033234
4 x DIAG TIE | +9.086 | +9.502 | 1250 | 0.0191695 | 0.0000220971

# IfcBeam: PL8*180 (38)
In: Undefined
Description: PL8*180; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +9.325; Top elevation: +9.605; Phase: 1; Class: 99
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 34.2 m2; Net surface area: 0.1 m2; Height: 180 mm; Width: 8 mm; Length: 280 mm
Pset_BeamCommon - LoadBearing: no; Reference: P0(?)
BaseQuantities - Length: 280 mm; OuterSurfaceArea: 0.10816 m2; NetVolume: 0.0004032 m3; NetWeight: 3.16512 kg

# IfcCovering: GALVANISED (266)
In: Undefined
Material: Undefined/Undefined

# IfcElementAssembly (1008)
In: Undefined
Name | Assembly/Cast unit weight (kg) | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Assembly/Cast unit Mark | Width (mm) | PredefinedType
DIAG TIE | 0 | +5.871 | +6.397 | 19>/B> | CR0(?) | 5
NOSNÍK | 15.9 | +5.736 | +5.917 | 18-19>/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 18-19/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 17-18/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 17-18/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 16-17/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 16-17/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 15-16/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 15-16/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 14-15/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 14-15/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 13-14/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 13-14/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 12-13/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 12-13/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 11-12/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 11-12/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 10-11/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 10-11/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 9-10/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 9-10/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 8-9/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 8-9/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 7-8/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 7-8/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 6-7/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 6-7/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 5-6/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 5-6/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 4-5/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 4-5/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 3-4/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 3-4/B> | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 2-3/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 2-3/B> | CR0(?) | 5
NOSNÍK | 15.9 | +5.736 | +5.917 | <1-2/B> | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 1-2/B> | CR0(?) | 5
DIAG TIE | 0 | +5.871 | +6.397 | <1/B> | CR0(?) | 5
DIAG TIE | 0 | +5.871 | +6.397 | 19>/<A | CR0(?) | 5
NOSNÍK | 15.9 | +5.736 | +5.917 | 18-19>/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 18-19/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 17-18/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 17-18/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 16-17/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 16-17/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 15-16/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 15-16/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 14-15/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 14-15/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 13-14/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 13-14/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 12-13/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 12-13/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 11-12/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 11-12/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 10-11/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 10-11/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 9-10/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 9-10/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 8-9/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 8-9/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 7-8/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 7-8/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 6-7/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 6-7/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 5-6/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 5-6/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 4-5/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 4-5/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 3-4/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 3-4/<A | CR0(?) | 5
2 x DIAG TIE | 0 | +5.866 | +6.403 | 2-3/<A | CR0(?) | 5
NOSNÍK | 12.1 | +5.736 | +5.917 | 2-3/<A | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +5.866 | +6.403 | 1-2/<A | CR0(?) | 5
NOSNÍK | 15.9 | +5.736 | +5.917 | <1-2/<A | B0(?) | 113.4 | RIGID_FRAME
DIAG TIE | 0 | +5.871 | +6.397 | <1/<A | CR0(?) | 5
2 x DIAG TIE | 0 | +9.086 | +9.502 | 19>/A-B | CR0(?) | 5
2 x NOSNÍK | 15.9 | +8.953 | +9.134 | 18-19>/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x DIAG TIE | 0 | +9.086 | +9.502 | <1/A-B | CR0(?) | 5
2 x NOSNÍK | 15.9 | +8.953 | +9.134 | <1-2/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 31.5 | +5.734 | +9.642 | <1/A-B> | B0(?) | 66 | RIGID_FRAME
NOSNÍK | 31.5 | +5.734 | +9.642 | <1/<A-B | B0(?) | 66 | RIGID_FRAME
NOSNÍK | 31.5 | +5.734 | +9.642 | 19>/A-B> | B0(?) | 66 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | <1/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 19>/A-B | CR0(?) | 47 | RIGID_FRAME
NOSNÍK | 31.5 | +5.734 | +9.642 | 19>/<A-B | B0(?) | 66 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 18-19/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 17-18/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 16-17/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 15-16/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 14-15/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 13-14/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 12-13/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 11-12/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 10-11/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 9-10/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 8-9/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 7-8/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 6-7/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 5-6/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 4-5/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 3-4/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 2-3/A-B | CR0(?) | 47 | RIGID_FRAME
APEX_ANGLE | 0.6 | +9.500 | +9.619 | 1-2/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 18-19/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 18-19/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 18-19/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 18-19/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 18-19/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 18-19/<A | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 18-19/B> | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 17-18/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 17-18/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 17-18/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 17-18/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 17-18/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 17-18/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 17-18/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 16-17/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 16-17/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 16-17/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 16-17/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 16-17/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 16-17/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 16-17/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 15-16/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 15-16/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 15-16/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 15-16/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 15-16/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 15-16/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 15-16/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 14-15/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 14-15/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 14-15/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 14-15/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 14-15/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 14-15/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 14-15/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 13-14/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 13-14/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 13-14/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 13-14/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 13-14/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 13-14/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 13-14/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 12-13/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 12-13/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 12-13/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 12-13/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 12-13/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 12-13/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 12-13/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 11-12/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 11-12/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 11-12/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 11-12/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 11-12/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 11-12/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 11-12/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 10-11/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 10-11/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 10-11/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 10-11/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 10-11/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 10-11/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 10-11/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 9-10/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 9-10/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 9-10/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 9-10/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 9-10/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 9-10/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 9-10/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 8-9/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 8-9/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 8-9/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 8-9/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 8-9/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 8-9/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 8-9/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 7-8/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 7-8/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 7-8/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 7-8/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 7-8/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 7-8/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 7-8/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 6-7/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 6-7/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 6-7/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 6-7/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 6-7/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 6-7/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 6-7/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 5-6/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 5-6/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 5-6/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 5-6/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 5-6/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 5-6/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 5-6/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 4-5/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 4-5/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 4-5/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 4-5/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 4-5/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 4-5/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 4-5/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 3-4/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 3-4/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 3-4/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 3-4/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 3-4/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 3-4/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 3-4/<A | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 2-3/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 2-3/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 2-3/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 2-3/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 2-3/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 2-3/B> | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 1.6 | +8.995 | +9.594 | 1-2/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +8.345 | +9.089 | 1-2/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.696 | +8.439 | 1-2/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +7.047 | +7.790 | 1-2/A-B | CR0(?) | 47 | RIGID_FRAME
2 x ANTI_SAG | 2 | +6.397 | +7.141 | 1-2/A-B | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 1-2/B> | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 2-3/<A | CR0(?) | 47 | RIGID_FRAME
ANTI_SAG | 2 | +5.777 | +6.491 | 1-2/<A | CR0(?) | 47 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 1/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 3/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 4/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 5/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 6/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 7/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 8/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 9/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 10/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 11/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 12/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 13/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 14/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 15/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 16/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 17/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 18/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 19/A-B> | B0(?) | 180 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 19/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 19/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 19/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 19/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 19/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 19/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 19/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 19/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 19/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 18/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 18/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 18/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 18/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 18/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 18/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 18/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 18/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 18/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 17/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 17/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 17/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 17/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 17/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 17/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 17/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 17/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 17/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 16/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 16/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 16/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 16/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 16/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 16/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 16/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 16/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 16/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 15/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 15/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 15/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 15/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 15/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 15/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 15/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 15/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 15/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 14/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 14/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 14/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 14/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 14/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 14/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 14/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 14/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 14/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 13/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 13/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 13/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 13/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 13/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 13/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 13/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 13/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 13/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 12/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 12/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 12/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 12/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 12/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 12/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 12/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 12/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 12/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 11/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 11/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 11/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 11/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 11/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 11/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 11/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 11/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 11/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 10/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 10/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 10/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 10/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 10/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 10/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 10/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 10/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 10/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 9/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 9/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 9/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 9/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 9/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 9/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 9/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 9/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 9/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 8/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 8/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 8/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 8/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 8/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 8/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 8/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 8/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 8/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 7/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 7/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 7/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 7/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 7/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 7/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 7/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 7/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 7/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 6/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 6/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 6/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 6/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 6/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 6/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 6/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 6/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 6/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 5/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 5/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 5/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 5/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 5/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 5/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 5/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 5/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 5/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 4/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 4/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 4/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 4/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 4/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 4/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 4/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 4/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 4/<A | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 3/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 3/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 3/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 3/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 3/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 3/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 3/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 3/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 3/<A | CR0(?) | 75 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 18/A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.651 | +7.832 | 18/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.950 | +9.130 | 18/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +9.456 | +9.636 | 18/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.301 | +8.481 | 18/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.002 | +7.183 | 18/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 18/<A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.950 | +9.130 | 17/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.651 | +7.832 | 17/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 17/A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +9.456 | +9.636 | 16/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.301 | +8.481 | 16/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.002 | +7.183 | 16/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 16/<A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.950 | +9.130 | 15/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.651 | +7.832 | 15/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 15/A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +9.456 | +9.636 | 14/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.301 | +8.481 | 14/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.002 | +7.183 | 14/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 14/<A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.950 | +9.130 | 13/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.651 | +7.832 | 13/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 13/A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +9.456 | +9.636 | 12/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.301 | +8.481 | 12/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.002 | +7.183 | 12/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 12/<A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.950 | +9.130 | 11/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.651 | +7.832 | 11/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 11/A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +9.456 | +9.636 | 10/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.301 | +8.481 | 10/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.002 | +7.183 | 10/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 10/<A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.950 | +9.130 | 9/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.651 | +7.832 | 9/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 9/A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +9.456 | +9.636 | 8/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.301 | +8.481 | 8/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.002 | +7.183 | 8/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 8/<A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.950 | +9.130 | 7/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.651 | +7.832 | 7/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 7/A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +9.456 | +9.636 | 6/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.301 | +8.481 | 6/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.002 | +7.183 | 6/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 6/<A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.950 | +9.130 | 5/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.651 | +7.832 | 5/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 5/A | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 17/B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 15/B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 13/B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 11/B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 9/B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 7/B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 5/B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 18/B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 18/B> | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 16/B> | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 14/B> | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 12/B> | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 10/B> | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 8/B> | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 6/B> | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +9.456 | +9.636 | 4/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.301 | +8.481 | 4/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.002 | +7.183 | 4/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 4/B> | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 4/<A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.950 | +9.130 | 3/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.651 | +7.832 | 3/A-B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 3/B | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 3/A | SA0(?) | 113.4 | RIGID_FRAME
2 x SLEEVE | 2.1 | +9.456 | +9.636 | 2/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 2/A-B | CR0(?) | 75 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.950 | +9.130 | 2/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 2/A-B | CR0(?) | 75 | RIGID_FRAME
2 x SLEEVE | 2.1 | +8.301 | +8.481 | 2/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 2/A-B | CR0(?) | 75 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.651 | +7.832 | 2/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 2/A-B | CR0(?) | 75 | RIGID_FRAME
2 x SLEEVE | 2.1 | +7.002 | +7.183 | 2/A-B | SA0(?) | 113.4 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 2/A-B | CR0(?) | 75 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 2/B | SA0(?) | 113.4 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 2/B | CR0(?) | 75 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 2/B> | SA0(?) | 113.4 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 2/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 2/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 2/<A | CR0(?) | 75 | RIGID_FRAME
SLEEVE | 2.1 | +6.353 | +6.533 | 2/A | SA0(?) | 113.4 | RIGID_FRAME
SLEEVE | 2.1 | +5.733 | +5.913 | 2/<A | SA0(?) | 113.4 | RIGID_FRAME
2 x CLEAT | 1 | +9.482 | +9.605 | 1/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.976 | +9.099 | 1/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +8.327 | +8.450 | 1/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.677 | +7.801 | 1/A-B | CR0(?) | 75 | RIGID_FRAME
2 x CLEAT | 1 | +7.028 | +7.151 | 1/A-B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 1/B | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 1/B> | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +6.379 | +6.502 | 1/A | CR0(?) | 75 | RIGID_FRAME
CLEAT | 1 | +5.759 | +5.882 | 1/<A | CR0(?) | 75 | RIGID_FRAME
2 x NOSNÍK | 15.9 | +9.459 | +9.640 | <1-2/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 15.9 | +8.304 | +8.485 | <1-2/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 15.9 | +7.655 | +7.835 | <1-2/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 15.9 | +7.005 | +7.186 | <1-2/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 15.9 | +6.356 | +6.537 | <1-2/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 15.9 | +6.356 | +6.537 | <1-2/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 15.9 | +9.459 | +9.640 | 18-19>/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 15.9 | +8.304 | +8.485 | 18-19>/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 15.9 | +7.655 | +7.835 | 18-19>/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 15.9 | +7.005 | +7.186 | 18-19>/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 15.9 | +6.356 | +6.537 | 18-19>/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 15.9 | +6.356 | +6.537 | 18-19>/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 17-18/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 17-18/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 17-18/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 17-18/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 17-18/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 17-18/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 17-18/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 16-17/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 16-17/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 16-17/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 16-17/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 16-17/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 16-17/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 16-17/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 15-16/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 15-16/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 15-16/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 15-16/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 15-16/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 15-16/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 15-16/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 14-15/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 14-15/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 14-15/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 14-15/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 14-15/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 14-15/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 14-15/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 13-14/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 13-14/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 13-14/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 13-14/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 13-14/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 13-14/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 13-14/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 12-13/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 12-13/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 12-13/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 12-13/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 12-13/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 12-13/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 12-13/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 11-12/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 11-12/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 11-12/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 11-12/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 11-12/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 11-12/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 11-12/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 10-11/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 10-11/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 10-11/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 10-11/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 10-11/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 10-11/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 10-11/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 9-10/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 9-10/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 9-10/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 9-10/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 9-10/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 9-10/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 9-10/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 8-9/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 8-9/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 8-9/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 8-9/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 8-9/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 8-9/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 8-9/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 7-8/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 7-8/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 7-8/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 7-8/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 7-8/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 7-8/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 7-8/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 6-7/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 6-7/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 6-7/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 6-7/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 6-7/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 6-7/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 6-7/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 5-6/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 5-6/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 5-6/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 5-6/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 5-6/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 5-6/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 5-6/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 4-5/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 4-5/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 4-5/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 4-5/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 4-5/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 4-5/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 4-5/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 3-4/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 3-4/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 3-4/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 3-4/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 3-4/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 3-4/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 3-4/A | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +9.459 | +9.640 | 2-3/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.953 | +9.134 | 2-3/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +8.304 | +8.485 | 2-3/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.655 | +7.835 | 2-3/A-B | B0(?) | 113.4 | RIGID_FRAME
2 x NOSNÍK | 12.1 | +7.005 | +7.186 | 2-3/A-B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 2-3/B | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 12.1 | +6.356 | +6.537 | 2-3/A | B0(?) | 113.4 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 19/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 18/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 17/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 16/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 15/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 14/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 13/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 12/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 11/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 10/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 9/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 8/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 7/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 6/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 5/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 4/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 3/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 2/A-B> | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 2/<A-B | B0(?) | 180 | RIGID_FRAME
NOSNÍK | 148.2 | +5.636 | +9.605 | 1/<A-B | B0(?) | 180 | RIGID_FRAME

# IfcMechanicalFastener: Bolt assembly (2019)
In: Undefined
Material: Undefined
Tekla Bolt - Washer type: 125A; Nut type: 934; Slotted hole y: 0 mm; Slotted hole x: 0 mm; Location: Montážní; Bolt Name: BOLT
Name | NominalDiameter (mm) = Washer diameter (mm) | NominalLength (mm) = Bolt length (mm) | Washer count | Washer name | Nut count | Nut name | Bolt hole diameter (mm) | Bolt count | Bolt size (mm) | Bolt standard
72 x Bolt assembly | 16 | 9.6 | 0 | WASHER-16-125A | 0 | NUT-16-934 | 18 | 1 | 18 | DIN931
1144 x Bolt assembly | 16 | 50 | 2 | WASHER-16-125A | 1 | NUT-16-934 | 18 | 1 | 16 | DIN931
8 x Bolt assembly | 16 | 1.6 | 0 | WASHER-16-125A | 0 | NUT-16-934 | 18 | 1 | 18 | DIN931
776 x Bolt assembly | 16 | 50 | 3 | WASHER-16-125A | 1 | NUT-16-934 | 18 | 1 | 16 | DIN931
19 x Bolt assembly | 20 | 40 | 4 | WASHER-20-125A | 4 | NUT-20-934 | 22 | 4 | 20 | 931N

# IfcMember: MET-2-147U13 (4)
In: Undefined
Description: MET-2-147U13; Material: STEEL/S450GD+Z
Tekla Common - Bottom elevation: +5.734; Top elevation: +9.642; Phase: 1; Class: 4
Tekla Quantity - Weight: 31.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 92.6 m2; Net surface area: 3.9 m2; Height: 147 mm; Width: 66 mm; Length: 7108.4 mm
Pset_MemberCommon - LoadBearing: yes; Reference: B0(?)
BaseQuantities - Length: 7108.39 mm; OuterSurfaceArea: 2.91444 m2; GrossSurfaceArea: 2.91444 m2; CrossSectionArea: 0.000564 m2; NetVolume: 0.00255419 m3; GrossVolume: 0.00400913 m3; NetWeight: 20.0504 kg; GrossWeight: 31.4717 kg

# IfcMember: MET-AS-142 (216)
In: Undefined
Description: MET-AS-142; Material: STEEL/S235JR
Pset_MemberCommon - LoadBearing: no; Reference: CR0(?)
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 112 mm; Width: 47 mm
BaseQuantities - CrossSectionArea: 0.000176 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) = GrossVolume (m3) | NetWeight (kg) = GrossWeight (kg)
36 x ANTI_SAG | +8.995 | +9.594 | 1.6 | 127 | 0.2 | 948.4 | 948.4 | 0.202188 | 0.000202822 | 1.59216
36 x ANTI_SAG | +8.345 | +9.089 | 2 | 127.6 | 0.3 | 1218.4 | 1218.4 | 0.250788 | 0.000250342 | 1.96519
36 x ANTI_SAG | +7.696 | +8.439 | 2 | 127.6 | 0.3 | 1218.4 | 1218.4 | 0.250788 | 0.000250342 | 1.96519
36 x ANTI_SAG | +7.047 | +7.790 | 2 | 127.6 | 0.3 | 1218.4 | 1218.4 | 0.250788 | 0.000250342 | 1.96519
36 x ANTI_SAG | +6.397 | +7.141 | 2 | 127.6 | 0.3 | 1218.4 | 1218.4 | 0.250788 | 0.000250342 | 1.96519
36 x ANTI_SAG | +5.777 | +6.491 | 2 | 127.5 | 0.2 | 1163.4 | 1163.39 | 0.240886 | 0.000240661 | 1.88919

# IfcMember: MET-DIAG-WIRE (4)
In: Undefined
Description: MET-DIAG-WIRE; Material: Undefined/43A
Tekla Common - Bottom elevation: +5.871; Top elevation: +6.397; Phase: 1; Class: 99
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0 m2; Height: 5 mm; Width: 5 mm; Length: 1410 mm
Pset_MemberCommon - LoadBearing: no; Reference: CR0(?)
BaseQuantities - Length: 1410 mm; OuterSurfaceArea: 0.0216187 m2; GrossSurfaceArea: 0 m2; CrossSectionArea: 0.000051 m2; NetVolume: 0.0000249255 m3; GrossVolume: 0.00007191 m3; NetWeight: 0 kg; GrossWeight: 0 kg

# IfcMember: PL5*130 (266)
In: Undefined
Description: PL5*130; Material: STEEL/S235JR
Tekla Common - Finish: GALVANISED; Phase: 1; Class: 99
Tekla Quantity - Weight: 0.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 54.7 m2; Net surface area: 0 m2; Height: 130 mm; Width: 5 mm; Length: 140 mm
Pset_MemberCommon - LoadBearing: no; Reference: P0(?)
BaseQuantities - Length: 140 mm; CrossSectionArea: 0.0007 m2
Name | Bottom elevation | Top elevation | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) = GrossVolume (m3) | NetWeight (kg) = GrossWeight (kg)
2 x CLEAT | +5.759 | +5.871 | 0.0390999 | 0.0000909998 | 0.714349
2 x CLEAT | +6.379 | +6.491 | 0.0390999 | 0.0000909998 | 0.714349
2 x CLEAT | +7.028 | +7.141 | 0.0390999 | 0.0000909998 | 0.714349
2 x CLEAT | +7.677 | +7.790 | 0.0390999 | 0.0000909998 | 0.714349
2 x CLEAT | +8.327 | +8.439 | 0.0390999 | 0.0000909998 | 0.714349
2 x CLEAT | +8.976 | +9.089 | 0.0390999 | 0.0000909998 | 0.714349
2 x CLEAT | +9.482 | +9.594 | 0.0390999 | 0.0000909998 | 0.714349
26 x CLEAT | +8.976 | +9.089 | 0.0391 | 0.000091 | 0.71435
26 x CLEAT | +7.677 | +7.790 | 0.0391 | 0.000091 | 0.71435
26 x CLEAT | +6.379 | +6.491 | 0.0391 | 0.000091 | 0.71435
11 x CLEAT | +9.482 | +9.594 | 0.0391 | 0.000091 | 0.71435
11 x CLEAT | +8.327 | +8.439 | 0.0391 | 0.000091 | 0.71435
11 x CLEAT | +7.028 | +7.141 | 0.0391 | 0.000091 | 0.71435
9 x CLEAT | +5.759 | +5.871 | 0.0391 | 0.000091 | 0.71435
8 x CLEAT | +8.976 | +9.089 | 0.0390997 | 0.0000909993 | 0.714345
8 x CLEAT | +7.677 | +7.790 | 0.0390997 | 0.0000909993 | 0.714345
8 x CLEAT | +6.379 | +6.491 | 0.0390997 | 0.0000909993 | 0.714345
23 x CLEAT | +9.482 | +9.594 | 0.0390997 | 0.0000909993 | 0.714345
23 x CLEAT | +8.327 | +8.439 | 0.0390997 | 0.0000909993 | 0.714345
23 x CLEAT | +7.028 | +7.141 | 0.0390997 | 0.0000909993 | 0.714345
25 x CLEAT | +5.759 | +5.871 | 0.0390997 | 0.0000909993 | 0.714345
2 x CLEAT | +9.482 | +9.594 | 0.0390998 | 0.0000909995 | 0.714346
2 x CLEAT | +8.976 | +9.089 | 0.0390998 | 0.0000909995 | 0.714346
2 x CLEAT | +8.327 | +8.439 | 0.0390998 | 0.0000909995 | 0.714346
2 x CLEAT | +7.677 | +7.790 | 0.0390998 | 0.0000909995 | 0.714346
2 x CLEAT | +7.028 | +7.141 | 0.0390998 | 0.0000909995 | 0.714346
2 x CLEAT | +6.379 | +6.491 | 0.0390998 | 0.0000909995 | 0.714346
2 x CLEAT | +5.759 | +5.871 | 0.0390998 | 0.0000909995 | 0.714346

# IfcMember: RHS110*160*5 (38)
In: Undefined
Description: RHS110*160*5; Material: STEEL/S235JR
Tekla Common - Bottom elevation: +5.636; Top elevation: +9.530; Phase: 1; Class: 11
Tekla Quantity - Weight: 145.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.7 m2; Net surface area: 3.9 m2; Height: 110 mm; Width: 160 mm; Length: 7141.8 mm
Pset_MemberCommon - LoadBearing: yes; Reference: Pr0(?)
BaseQuantities - Length: 7141.75 mm; OuterSurfaceArea: 3.87469 m2; GrossSurfaceArea: 3.87469 m2; CrossSectionArea: 0.00252961 m2; NetVolume: 0.0184787 m3; GrossVolume: 0.0184787 m3; NetWeight: 145.057 kg; GrossWeight: 145.057 kg

# IfcPlate: PL5*70 (266)
In: Undefined
Description: PL5*70; Material: STEEL/S235JR
Tekla Common - Phase: 1; Class: 1
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 58.5 m2; Net surface area: 0 m2; Height: 70 mm; Width: 5 mm; Length: 130 mm
Pset_PlateCommon - LoadBearing: yes; Reference: Pr0(?)
BaseQuantities - Width: 70 mm; NetArea: 0.0139999 m2; GrossArea: 0.00909996 m2; CrossSectionArea: 0.000025 m2; NetVolume: 0.0000304999 m3; GrossVolume: 0.0000304999 m3
Name | Bottom elevation | Top elevation
38 x PLECH | +9.484 | +9.605
38 x PLECH | +8.979 | +9.099
38 x PLECH | +8.329 | +8.450
38 x PLECH | +7.680 | +7.801
38 x PLECH | +7.031 | +7.151
38 x PLECH | +6.381 | +6.502
38 x PLECH | +5.761 | +5.882
